# Keil uVision project HAKKO.uvproj, settings and files
target HAKKO (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: HAKKO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Lib;..\User
  group User
    ../User/: main.c Sys_Init.c LQ12864.c EC11.c Control.c
  group Lib
    ./: STARTUP.A51
    ../Lib/: delay.c EEPROM.c Exti.c GPIO.c PCA.c timer.c config.h ADC.c
