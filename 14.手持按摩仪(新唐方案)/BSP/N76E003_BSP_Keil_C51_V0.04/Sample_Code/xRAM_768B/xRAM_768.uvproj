# Keil uVision project xRAM_768.uvproj, settings and files
target xRAM256 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: xRAM_768 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Include
  group Source
    ./Code/: xRAM_768byte.c
    C:/Keil/C51/LIB/: C51L.LIB
