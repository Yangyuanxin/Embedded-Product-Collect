# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: fromelf --bin --output .\FW\fw_update.bin .\out\template.axf
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c include: .\FWLib\inc;.\src;.\TCPnet;.\RTT;.\uip\core;.\uip\port;.\uip\app;.\rtx
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWLib
    ./FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_spi.c
    ./FWLib/startup/: system_stm32f10x.c startup_stm32f10x_cl.s
  group rtt
    ./rtt/: SEGGER_RTT.c SEGGER_RTT_Printf.c
  group rtx
    ./rtx/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c SVC_Table.s RTX_Conf_CM.c
  group uip
    ./uip/app/: dhcpc.c tcp.c udp.c uIPMain.c
    ./uip/core/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
    ./uip/port/: clock-arch.c stm32_eth.c tapdev.c
  group src
    ./src/: hw.c sys_cfg.c lcd.c block_fifo.c shk.c bms.c bms_gb.c bms_pt.c em.c rtc.c led.c lcd_ui.c eth.c ic.c measure.c delay.c server.c sflash.c evc.c gprs.c recorder.c io.c bms_xgb.c
  group main
    ./src/: main.c
software components: CMSIS:CORE 5.0.1
