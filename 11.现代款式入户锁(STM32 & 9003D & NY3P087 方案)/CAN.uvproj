# Keil uVision project CAN.uvproj, settings and files
target CAN (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: release +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Source
    ./: main.c
    ./src/: arch.c init.c charQue.c driver.c func_idle.c f_finger.c f_Unlock.c f_key.c l_fingprint.c f_nokey.c l_voicePrompt.c f_test.c
  group Interrupts
    ./: stm32f10x_it.c
  group Library
    d:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB
  group Documentation
    ./: readme.txt
