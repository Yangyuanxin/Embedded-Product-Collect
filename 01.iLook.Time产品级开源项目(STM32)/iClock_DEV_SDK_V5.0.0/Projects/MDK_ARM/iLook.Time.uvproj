# Keil uVision project iLook.Time.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: iLook.Time +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\Driver\inc;..\Common\inc;..\Mass_Storage\inc;..\..\Projects;..\System\inc;..\GUI\inc;..\algorithm;..\FATfs;..\file;..\iClock_Test0;..\iClock_Test0\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: hw_config.c stm32_it.c main.c
  group CMSIS
    ../: system_stm32f10x.c
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/: startup_stm32f10x_hd.s
  group USB-FS-Device_Driver
    ../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_wwdg.c
  group Driver
    ../Driver/src/: spiflash.c rtc.c displayer_T.c sof_iic.c
  group Mass_Stoage
    ../Mass_Storage/src/: mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group System
    ../System/src/: sys_tick.c sys_mem.c sys_hw.c task.c
  group GUI
    ../GUI/src/: graphical.c
  group Comm
    ../Common/src/: datetime.c my_string.c
  group FATfs
    ../FATfs/: diskio.c ff.c
  group iClock_Test0
    ../file/: iclock_file.c
    ../iClock_Test0/src/: basic_task.c ui.c
