# Keil uVision project Charger.uvprojx, settings and files
target Charger (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Charger +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FWLIB\inc;..\HARDWARE\BL8025;..\HARDWARE\IIC;..\HARDWARE\TIMER;..\HARDWARE\ADC3;..\HARDWARE\Current;..\HARDWARE\WATCHDOG;..\HARDWARE\RS485;..\HARDWARE\CRC;..\HARDWARE\RELAY;..\HARDWARE\ACPowerDetection
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/BL8025/: BL8025.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC3/: adc3.c
    ../HARDWARE/RS485/: RS485.c
    ../HARDWARE/WATCHDOG/: WatchDog.c
    ../HARDWARE/Current/: Current.c
    ../HARDWARE/CRC/: CRC.c
    ../HARDWARE/RELAY/: Relay.c
    ../HARDWARE/ACPowerDetection/: ACPowerDetection.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_adc.c
  group README
    ../: readme.txt
