# Keil uVision project STM32_3DPrinter_firmware.uvprojx, settings and files
target 3Dprinter_firmware (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_3DPrinter_firmware +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSIS;..\FWLIB\inc;..\USER;..\HARDWARE\beep;..\HARDWARE\24cxx;..\HARDWARE\flash;..\HARDWARE\motion_control;..\HARDWARE\planner;..\HARDWARE\rtc;..\HARDWARE\sram;..\HARDWARE\step_motor;..\HARDWARE\thermistor;..\HARDWARE\led;..\SYSTEM\adc;..\SYSTEM\iic;..\SYSTEM\spi;..\SYSTEM\sys;..\SYSTEM\timer;..\SYSTEM\usart;..\SYSTEM\watchdog;..\SYSTEM\delay;..\HARDWARE\lcd;..\HARDWARE\lcd_touch;..\HARDWARE\sdio;..\SOFTWARE\MALLOC;..\SOFTWARE\FATFS\exfuns;..\SOFTWARE\FATFS\src;..\SOFTWARE\FONT;..\SOFTWARE\PICTURE;..\SOFTWARE\GUI;..\SOFTWARE\MENU;..\HARDWARE\key;..\USER\CARDREAD;..\HARDWARE\LCD12864;..\SYSTEM\exti
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c marlin_main.c ConfigurationStore.c Configuration.h Configuration_adv.h language.h pins.h include_conf.h
    ../USER/CARDREAD/: cardreader.c
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/24cxx/: 24cxx.c
    ../HARDWARE/flash/: flash.c
    ../HARDWARE/rtc/: rtc.c
    ../HARDWARE/sram/: sram.c
    ../HARDWARE/planner/: planner.c
    ../HARDWARE/step_motor/: stepper.c
    ../HARDWARE/motion_control/: motion_control.c
    ../HARDWARE/thermistor/: temperature.c
    ../HARDWARE/lcd/: lcd.c
    ../HARDWARE/lcd_touch/: touch.c
    ../HARDWARE/sdio/: sdio_sdcard.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/LCD12864/: lcd12864.c lcd12864_menu.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/adc/: adc.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/iic/: iic.c
    ../SYSTEM/spi/: spi.c
    ../SYSTEM/watchdog/: watchdog.c
    ../SYSTEM/exti/: exti.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTCODE
    ../STARTCODE/: startup_stm32f10x_hd.s
  group DOC
    ../DOC/: readme.txt updata_log.txt
  group MALLOC
    ../SOFTWARE/MALLOC/: malloc.c
  group FATFS
    ../SOFTWARE/FATFS/exfuns/: exfuns.c mycc936.c
    ../SOFTWARE/FATFS/src/: diskio.c ff.c
  group FONT
    ../SOFTWARE/FONT/: fontshow.c fontupd.c
  group PICTURE
    ../SOFTWARE/PICTURE/: bmp.c gif.c jpeg.c picdecode.c picture_conf.h
