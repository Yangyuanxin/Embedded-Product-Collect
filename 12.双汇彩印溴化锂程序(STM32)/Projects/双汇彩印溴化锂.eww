<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\XIU_HUA_LI.ewp</path>
  </project>
  <batchBuild/>
</workspace>


