# IAR project Backup of LUOHEI_120T.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\App; ..\HAL; ..\KEY; ..\can_process; ..\VIEW; ..\PARA; ..\RELAY; ..\PAIWU; ..\MODBUS; ..\KI; ..\HAL\Common; ..\HAL\include; ..\HAL\Target; ..\HAL\Config; ..\uCOS-II\Ports; ..\uCOS-II\Source; ..\uCOS-II\Config; ..\STM32F10xFWLib\FWLib\library\inc; ..\STM32F10xFWLib\FWLib\library\src; ..\uart; ..\measure; ..\led; ..\lcd; ..\gui; ..\gui\zlg_gui; ..\gui\CURSOR; ..\gui\LCD_FORM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\App; ..\HAL; ..\HAL\Common; ..\HAL\include; ..\HAL\Target; ..\HAL\Config; ..\uCOS-II\Ports; ..\uCOS-II\Source; ..\uCOS-II\Config; ..\STM32F10xFWLib\FWLib\library\inc; ..\STM32F10xFWLib\FWLib\library\src
  OBJCOPY.OOCOutputFile: 通用程序.hex
  ILINK.IlinkOutputFile: STM32.out
  ILINK.IlinkIcfFile: ..\HAL\Config\STM32_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 软件说明.txt
  group App
    ./: head.h
    ../App/: main.c
  group App/Config
    ../App/: app_cfg.h Task_includes.h
  group App/OS_App
    ../App/: CreateEvents.C CreateMultiTask.C
  group DRIVER/GUI
    ../GUI/ZLG_GUI/: ConvertColor.c convertcolor.h FONT16_16.C font16_16.h FONT24_32.C font24_32.h font5_7.c font5_7.h FONT8_8.C FONT8_8.H font_macro.h GUI_BASIC.C gui_basic.h GUI_CONFIG.H GUI_StockC.C gui_stockc.h loadbit.c Loadbit.h menu.c menu.h spline.c spline.h windows.c windows.h
    ../GUI/LCD_FORM/: LCD_INTERFACE.C lcd_interface.h
    ../VIEW/: view.c view.h
  group DRIVER/KEY
    ../KEY/: key.c key.h
  group DRIVER/KI
    ../KI/: ki.c ki.h
  group DRIVER/LCD
    ../LCD/: comm.c comm.h LCD_PROTOCOL.C lcd_protocol.h SPI_12864LCD.C SPI_12864LCD.H
  group DRIVER/LED
    ../LED/: led.c led.h
  group DRIVER/MEASURE
    ../measure/: measure.c measure.h
  group DRIVER/MODBUS
    ../MODBUS/: MODBUS.C MODBUS.H MODBUS_MASTER.C MODBUS_MASTER.H
  group DRIVER/PAIWU
    ../PAIWU/: PAIWU.C PAIWU.H
  group DRIVER/PARA
    ../PARA/: iap.c iap.h PARA.C para.h
  group DRIVER/RELAY
    ../RELAY/: relay.c relay.h
  group DRIVER/UART
    ../UART/: uart.c uart.h
  group HAL/Config
    ./: Readme.txt
    ../HAL/Config/: STM32_Flash.icf STM32_Flash.mac STM32_Flash_XRAM.icf STM32_Flash_XRAM.mac
  group HAL/Target
    ../HAL/target/: BoardInit.c cortexm3_macro.s low_level_init.c stm32f10x_it.c stm32f10x_it.h stm32f10x_vector.c
  group OS/uCOS-II/Configuration
    ../uCOS-II/Config/: os_cfg.h
  group OS/uCOS-II/Port
    ../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group OS/uCOS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group STM32F10xFWLib
    ../STM32F10xFWLib/: version.txt
  group STM32F10xFWLib/Config
    ../HAL/target/: stm32f10x_conf.h
  group STM32F10xFWLib/inc
    ../STM32F10xFWLib/FWLib/library/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_crc.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_type.h stm32f10x_usart.h
  group STM32F10xFWLib/inc/Unused
    ../STM32F10xFWLib/FWLib/library/inc/: stm32f10x_can.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_sdio.h stm32f10x_tim.h stm32f10x_wwdg.h
  group STM32F10xFWLib/src
    ../STM32F10xFWLib/FWLib/library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32F10xFWLib/src/Unused
    ../STM32F10xFWLib/FWLib/library/src/: stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_wwdg.c
