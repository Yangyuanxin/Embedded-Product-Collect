# Keil uVision project XYJ.uvprojx, settings and files
target XYJ (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XYJ2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_ MD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\CORE;..\USRE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\LCD12864;..\HARDWARE\PWM;..\HARDWARE\TIM2;..\HARDWARE\MOTOR;..\HARDWARE\Hongwai;..\HARDWARE\SHUI;..\HARDWARE\SHUI
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_cec.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD12864/: LCD12864.C
    ../HARDWARE/PWM/: PWM.C
    ../HARDWARE/TIM2/: TIMER2.C
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/Hongwai/: HONG.C
    ../HARDWARE/SHUI/: shui.c
