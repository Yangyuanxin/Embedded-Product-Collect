# Keil uVision project 加密设备项目.uvprojx, settings and files
target LoRa加密设备 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoRa_TEST +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CRC;.\MCU_ID;.\Modules_Init;..\MySelfAPI\MyDelay;..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\ZM470SX1276\platform;..\HARDWARE\ZM470SX1276\radio;..\HARDWARE\ZM470SX1276\sx1276;..\HARDWARE\ZM470SX1276\sx1276-Hal;..\HARDWARE\ZM470SX1276\sx1276-LoRa;..\HARDWARE\ZM470SX1276\sx1276-LoRaMisc;..\HARDWARE\LoRaSPI_Init;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\ComStatusKey;..\HARDWARE\LoRa_PWR;..\HARDWARE\TIMER3;..\HARDWARE\Relay;..\HARDWARE\LoRa;..\HARDWARE\IIC;..\HARDWARE\AdvanceTimer;..\HARDWARE\OrdinaryTimer;..\HARDWARE\SM2-SM4;..\HARDWARE\HSC32I1;..\HARDWARE\HSC32_RST;..\HARDWARE\HostComProtocol;..\HARDWARE\RTC;..\MySelfAPI\DmaUsart;..\MySelfAPI\APIOfPath;..\HARDWARE\W25Qxx\w25qxx_flash;..\HARDWARE\W25Qxx\w25qxx_init;..\HARDWARE\W25Qxx\RestoreLog;..\HARDWARE\DIPswitch;.\CRC\old;.\TheLoRaDeviceTask;..\HARDWARE\LoRaDataHandle\MasterHandle;..\HARDWARE\LoRaDataHandle\SlaveHandle;.\UpdateFirmware;..\HARDWARE\LoRaDataHandle\LoRaProtocolCmd;..\HARDWARE\LoRaDataHandle\HostComDataHandle;..\HARDWARE\WatchDog;..\HARDWARE\SM2-SM4\UpDateSM4Key;..\MySelfAPI\AppTest;..\HARDWARE\Alam;..\HARDWARE\CollectVoltage;..\HARDWARE\CollectVoltage
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_adc.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group MyAPI
    ../MySelfAPI/DmaUsart/: dma_usart.c
    ../MySelfAPI/MyDelay/: my_delay.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ./Modules_Init/: modules_init.c
    ./MCU_ID/: mcu_id.c
    ./CRC/: updata_crc.c
  group TheLoRaDeviceTask
    ./TheLoRaDeviceTask/: LoRaDeviceTask.c
  group HARDWARE
    ../HARDWARE/AdvanceTimer/: advance_timer.c
    ../HARDWARE/Alam/: alam.c
    ../HARDWARE/CollectVoltage/: CollectVoltage.c
    ../HARDWARE/ComStatusKey/: com_status_key_init.c
    ../HARDWARE/DIPswitch/: dip_switch.c
    ../HARDWARE/HSC32_RST/: hsc32_rst_io.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LoRaSPI_Init/: lora_spi_init.c
    ../HARDWARE/LoRa_PWR/: lora_pwr.c
    ../HARDWARE/OrdinaryTimer/: ordinary_timer.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/WatchDog/: WatchDog.c
  group W25Qxx
    ../HARDWARE/W25Qxx/w25qxx_init/: w25qxx_init.c
    ../HARDWARE/W25Qxx/w25qxx_flash/: w25qxx_flash.c
    ../HARDWARE/W25Qxx/RestoreLog/: xLog.c
  group HSC32I1
    ../HARDWARE/HSC32I1/: hsc32i1.c
    ../HARDWARE/SM2-SM4/: my_sm2.c
    ../HARDWARE/SM2-SM4/UpDateSM4Key/: update_sm4key.c
  group SX1276-LoRa
    ../HARDWARE/ZM470SX1276/radio/: radio.c
    ../HARDWARE/ZM470SX1276/sx1276/: sx1276.c
    ../HARDWARE/ZM470SX1276/sx1276-Hal/: sx1276-Hal.c
    ../HARDWARE/ZM470SX1276/sx1276-LoRa/: sx1276-LoRa.c
    ../HARDWARE/ZM470SX1276/sx1276-LoRaMisc/: sx1276-LoRaMisc.c
  group LoRaDataHandle
    ../HARDWARE/LoRa/: lora.c
    ../HARDWARE/LoRaDataHandle/LoRaProtocolCmd/: LoRaProtocolCmd.c
    ../HARDWARE/LoRaDataHandle/MasterHandle/: MasterLoRaHandle.c
    ../HARDWARE/LoRaDataHandle/SlaveHandle/: SlaveLoRaHandle.c
    ../HARDWARE/LoRaDataHandle/HostComDataHandle/: HostComDataHandle.c
  group HostComProtocol
    ../HARDWARE/HostComProtocol/: hostcomprotocol.c
  group UpdateFirmware
    ./UpdateFirmware/: UpdateFirmware.c
  group README
    ../README/: readme.txt
