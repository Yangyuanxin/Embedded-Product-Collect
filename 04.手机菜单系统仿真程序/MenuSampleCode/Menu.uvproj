# Keil uVision project Menu.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: menu +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Src/: Main.C Ks0108.C MenuTop.C MenuFSM.C MenuFunc.C MenuLanguage.C MenuMeasure.C MenuPara.C KeyScan.C Menu.C MenuMain.C
